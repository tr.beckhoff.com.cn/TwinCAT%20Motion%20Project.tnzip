TYPE ST_axis_Vel :
STRUCT
	  Axis_Vel:REAL;  //绝对移动速度
	  Axis_Acc:REAL;  //移动加速度
	  Axis_Dec:REAL;  //移动减速度
	  Axis_Jerk:REAL;//移动加加速度
END_STRUCT
END_TYPE
