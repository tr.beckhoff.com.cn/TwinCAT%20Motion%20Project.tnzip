PROGRAM MAIN
VAR
	Axis: FB_NcAxis;
END_VAR

Axis.TestMode();

END_PROGRAM
